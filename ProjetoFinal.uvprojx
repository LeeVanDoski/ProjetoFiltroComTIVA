# Keil uVision project ProjetoFinal.uvprojx, settings and files
target ProjetoFinal (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ProjetoFinal
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\src_my;.\src_others;..\..\TivaWare_C_Series-2.2.0.295;..\..\threadx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src_my
    ./src_my/: main.c main.h LCD.c LCD.h
  group src_others
    ./src_others/: uartstdio.c tx_initialize_low_level.s Crystalfontz128x128_ST7735.c Crystalfontz128x128_ST7735.h HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.c HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.h
    ../../TivaWare_C_Series-2.2.0.295/grlib/fonts/: fontfixed6x8.c
  group Libraries
    ../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../../threadx/ports/cortex_m4/keil/example_build/: ThreadX_Library.lib
    ../../TivaWare_C_Series-2.2.0.295/grlib/rvmdk/: grlib.lib
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2, Device:Startup 1.0.0
